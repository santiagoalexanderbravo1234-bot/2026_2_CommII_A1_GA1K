options:
  parameters:
    author: Grupo A1-GG
    description: Recibe la senal de FSK_DCI_Fase3_Tx_USRP2920. Filtro de canal, discriminador de frecuencia, filtro acoplado, correccion del desvio Tx-Rx, sincronismo de bit (Gardner) y deteccion del mensaje.
    generate_options: qt_gui
    id: FSK_Rx_USRP2920_UHD
    output_language: python
    title: 'FSK Rx USRP-2920 a 895 MHz: recepcion del mensaje conocido'
  states: {}

blocks:
- name: Rb
  id: variable
  parameters:
    value: '9600'
    comment: Tasa de bits [b/s] (igual al Tx)
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: h
  id: variable
  parameters:
    value: '1.0'
    comment: Indice de modulacion (igual al Tx)
  states: {}
- name: desviacion
  id: variable
  parameters:
    value: h*Rb/2
    comment: Desviacion de frecuencia [Hz] (igual al Tx)
  states: {}
- name: mensaje
  id: variable
  parameters:
    value: '"UIS - Comunicaciones II - Grupo A1-GG - Enlace FSK DCI. "'
  states: {}
- name: samp_rate_usrp
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: interp_rx
  id: variable
  parameters:
    value: int(samp_rate/math.gcd(int(samp_rate_usrp),int(samp_rate)))
  states: {}
- name: decim_rx
  id: variable
  parameters:
    value: int(samp_rate_usrp/math.gcd(int(samp_rate_usrp),int(samp_rate)))
  states: {}
- name: fc
  id: variable
  parameters:
    value: 895e6
    comment: Misma portadora del Tx
  states: {}
- name: usrp_addr
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
    comment: IP de la USRP receptora
  states: {}
- name: bw_canal
  id: variable
  parameters:
    value: desviacion + Rb
    comment: 'Corte del filtro de canal: media banda de Carson'
  states: {}
- name: trans_canal
  id: variable
  parameters:
    value: Rb/2
    comment: Banda de transicion del filtro de canal
  states: {}
- name: alpha_dc
  id: variable
  parameters:
    value: 1.0/(Sps*1000)
    comment: Constante del promedio (~1000 bits) que estima el desvio Tx-Rx
  states: {}
- name: clk_bw
  id: variable
  parameters:
    value: '0.045'
    comment: Ancho de banda del lazo de sincronismo de bit
  states: {}
- name: media_nrz
  id: variable
  parameters:
    value: 2.0*sum(bin(c).count('1') for c in mensaje.encode('ascii'))/(8*len(mensaje)) - 1
    comment: Valor medio de los bits NRZ del mensaje (para no confundirlo con desvio de frecuencia)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: ganancia_rx
  id: variable_qtgui_range
  parameters:
    label: '"Ganancia Rx [dB]"'
    value: '20'
    start: '0'
    stop: '31.5'
    step: '0.5'
    gui_hint: 0,0,1,2
  states: {}
- name: lbl_mensaje_tx
  id: variable_qtgui_label
  parameters:
    label: '"Mensaje esperado "'
    type: string
    value: mensaje
    gui_hint: 1,0,1,2
  states: {}
- name: texto_rx
  id: variable_function_probe
  parameters:
    block_id: detector_mensaje
    function_name: texto
    poll_rate: '4'
    value: '""'
  states: {}
- name: cer
  id: variable_function_probe
  parameters:
    block_id: detector_mensaje
    function_name: tasa_error_caracter
    poll_rate: '4'
    value: '0'
  states: {}
- name: estado_rx
  id: variable_function_probe
  parameters:
    block_id: detector_mensaje
    function_name: estado
    poll_rate: '4'
    value: '"Buscando el mensaje..."'
  states: {}
- name: lbl_mensaje_rx
  id: variable_qtgui_label
  parameters:
    label: '"Mensaje recibido "'
    type: string
    value: texto_rx
    gui_hint: 2,0,1,2
  states: {}
- name: lbl_cer
  id: variable_qtgui_label
  parameters:
    label: '"Tasa de error de caracter"'
    type: real
    value: cer
    gui_hint: 3,0,1,1
  states: {}
- name: lbl_estado
  id: variable_qtgui_label
  parameters:
    label: '"Estado"'
    type: string
    value: estado_rx
    gui_hint: 4,0,1,2
  states: {}
- name: usrp_rx
  id: uhd_usrp_source
  parameters:
    type: fc32
    otw: sc16
    dev_addr: usrp_addr
    dev_args: '""'
    sync: none
    samp_rate: samp_rate_usrp
    center_freq0: fc
    gain0: ganancia_rx
    ant0: '"RX2"'
    dc_offs_enb0: 'True'
    iq_imbal_enb0: 'True'
    comment: 'USRP receptora: antena en RX2, 895 MHz'
  states: {}
- name: adaptacion_tasa
  id: rational_resampler_xxx
  parameters:
    type: ccc
    interp: interp_rx
    decim: decim_rx
    taps: ''
    fbw: '0.4'
    comment: 250 -> 96 kS/s (48/125), Sps = 10
  states: {}
- name: filtro_canal
  id: low_pass_filter
  parameters:
    type: fir_filter_ccf
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    cutoff_freq: bw_canal
    width: trans_canal
    win: window.WIN_HAMMING
    comment: Deja pasar los dos tonos y limita el ruido antes del discriminador
  states: {}
- name: demod_fsk
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*desviacion)
    comment: 'Discriminador: tono alto -> +1, tono bajo -> -1'
  states: {}
- name: filtro_acoplado
  id: fir_filter_xxx
  parameters:
    type: fff
    decim: '1'
    taps: '[1.0/Sps]*Sps'
    comment: Integra un bit (pulso rectangular)
  states: {}
- name: media_desvio
  id: single_pole_iir_filter_xx
  parameters:
    type: float
    alpha: alpha_dc
    comment: Promedio lento = desvio de frecuencia Tx-Rx (normalizado)
  states: {}
- name: quitar_desvio
  id: blocks_sub_xx
  parameters:
    type: float
    comment: Corrige el desvio de frecuencia entre las USRP
  states: {}
- name: sincronismo_bit
  id: digital_symbol_sync_xx
  parameters:
    type: ff
    ted_type: digital.TED_GARDNER
    sps: Sps
    ted_gain: '1.0'
    loop_bw: clk_bw
    damping: '1.0'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    comment: 'Reloj de bit (Gardner): una muestra por bit en el centro del ojo'
  states: {}
- name: detector_mensaje
  id: epy_block
  parameters:
    _source_code: |
      """
      Detector del mensaje conocido para FSK binaria (recepcion con USRP).
      Entrada: una muestra blanda por bit (salida del Symbol Sync): cerca de +1 para el
      tono alto (fc + desviacion, bit 1) y cerca de -1 para el tono bajo (fc - desviacion, bit 0).
      El receptor real tiene incognitas que el simulador no tenia; aqui se resuelven asi:
        - umbral de decision: punto medio entre los dos niveles recibidos (k-medias con 2 grupos),
          para que un desvio de frecuencia residual o un mensaje con mas ceros que unos no lo sesgue,
        - polaridad (tonos intercambiados si el espectro llega invertido),
        - en que bit empieza cada byte (8 posibilidades),
        - en que caracter del mensaje empieza la ventana.
      Como el mensaje es conocido, se prueban las 16 combinaciones de polaridad y alineacion y se
      elige la que mas caracteres acierta; con ella se muestran el texto recibido y la tasa de error
      de caracter.
      """
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          def __init__(self, mensaje='UIS - Comunicaciones II - Grupo A1-GG - Enlace FSK DCI. ', ventanas=2):
              gr.sync_block.__init__(self, name='Detector de mensaje FSK', in_sig=[np.float32], out_sig=None)
              self.ref = np.frombuffer(mensaje.encode('ascii'), dtype=np.uint8)
              self.L = len(self.ref)
              self.nb = self.L * ventanas                    # bytes por ventana de analisis
              self.nbits = 8 * self.nb + 7                   # bits por ventana (+7 para probar alineaciones)
              self.buf = np.zeros(0, dtype=np.float32)
              # tabla de referencia con todos los desplazamientos ciclicos del mensaje
              idx = (np.arange(self.L)[:, None] + np.arange(self.nb)[None, :]) % self.L
              self.ref_shifts = self.ref[idx]                # (L, nb)
              self.ultimo = ''
              self.invertida = False
              self.n_car = 0
              self.n_err = 0
              self.cer_ventana = 1.0
              self.snr_db = 0.0
              self.enganchado = False

          def _umbral(self, x):
              u = float(np.mean(x))
              for _ in range(10):
                  alto = x[x > u]
                  bajo = x[x <= u]
                  if len(alto) == 0 or len(bajo) == 0:
                      return u
                  nuevo = 0.5 * (float(alto.mean()) + float(bajo.mean()))
                  if abs(nuevo - u) < 1e-6:
                      break
                  u = nuevo
              d = 0.5 * (float(alto.mean()) - float(bajo.mean()))
              var = (float(alto.var()) * len(alto) + float(bajo.var()) * len(bajo)) / len(x)
              self.snr_db = 10.0 * np.log10(d * d / var) if var > 0 else 99.0
              return u

          def _analizar(self, x):
              u = self._umbral(x)
              bits = (x > u).astype(np.uint8)
              mejor = (-1, 0, 0, None)
              for pol in (0, 1):
                  bp = bits ^ pol
                  for off in range(8):
                      b = np.packbits(bp[off:off + 8 * self.nb])          # MSB primero
                      aciertos = (self.ref_shifts == b[None, :]).sum(axis=1)
                      k = int(np.argmax(aciertos))
                      if aciertos[k] > mejor[0]:
                          mejor = (int(aciertos[k]), pol, k, b)
              acier, pol, k, b = mejor
              self.invertida = bool(pol)
              self.cer_ventana = 1.0 - acier / self.nb
              # el conteo empieza cuando el receptor se engancha (primera ventana con menos de 25 % de
              # error), para que la adquisicion del sincronismo de bit no infle la tasa de error
              if not self.enganchado and self.cer_ventana < 0.25:
                  self.enganchado = True
              if self.enganchado:
                  self.n_car += self.nb
                  self.n_err += self.nb - acier
              ini = (-k) % self.L                            # posicion donde empieza el mensaje
              linea = b[ini:ini + self.L]
              self.ultimo = ''.join(chr(c) if 32 <= c < 127 else '?' for c in linea)

          def work(self, input_items, output_items):
              x = input_items[0]
              self.buf = np.concatenate((self.buf, x))
              while len(self.buf) >= self.nbits:
                  self._analizar(self.buf[:self.nbits])
                  self.buf = self.buf[self.nbits:]
              return len(x)

          def texto(self):
              return self.ultimo

          def tasa_error_caracter(self):
              return self.n_err / self.n_car if self.n_car else 0.0

          def estado(self):
              if not self.enganchado:
                  return 'Buscando el mensaje...'
              return 'Enganchado | polaridad %s | error ultima ventana: %.1f %% | SNR en el decisor: %.1f dB' % (
                  'invertida' if self.invertida else 'normal', 100 * self.cer_ventana, self.snr_db)
    mensaje: mensaje
    ventanas: '2'
  states: {}
- name: restar_media_datos
  id: blocks_add_const_vxx
  parameters:
    type: float
    const: '-media_nrz'
  states: {}
- name: a_hz
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: desviacion
  states: {}
- name: desvio_freq
  id: qtgui_number_sink
  parameters:
    name: '"Desvio de frecuencia Tx-Rx estimado [Hz]"'
    type: float
    avg: '0.1'
    graph_type: qtgui.NUM_GRAPH_NONE
    min: '-10000'
    max: '10000'
    gui_hint: 3,1,1,1
    label1: '"Hz"'
  states: {}
- name: espectro_rx
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '"Espectro recibido (centrado en fc)"'
    fftsize: '2048'
    fc: fc
    bw: samp_rate_usrp
    grid: 'True'
    average: '0.2'
    ymin: '-120'
    ymax: '0'
    gui_hint: 5,0,4,1
    legend: 'False'
  states: {}
- name: senal_demodulada
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 5,1,2,1
    label1: Frecuencia normalizada
    legend: 'False'
    name: '"Salida del discriminador (filtro acoplado, sin desvio)"'
    size: '400'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: bits_rx
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 7,1,2,1
    label1: Bits
    legend: 'False'
    marker1: '0'
    name: '"Muestras de decision (1 por bit): dos niveles = dos tonos"'
    size: '256'
    srate: Rb
    style1: '0'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [usrp_rx, '0', adaptacion_tasa, '0']
- [usrp_rx, '0', espectro_rx, '0']
- [adaptacion_tasa, '0', filtro_canal, '0']
- [filtro_canal, '0', demod_fsk, '0']
- [demod_fsk, '0', filtro_acoplado, '0']
- [filtro_acoplado, '0', quitar_desvio, '0']
- [filtro_acoplado, '0', media_desvio, '0']
- [media_desvio, '0', quitar_desvio, '1']
- [media_desvio, '0', restar_media_datos, '0']
- [restar_media_datos, '0', a_hz, '0']
- [a_hz, '0', desvio_freq, '0']
- [quitar_desvio, '0', sincronismo_bit, '0']
- [quitar_desvio, '0', senal_demodulada, '0']
- [sincronismo_bit, '0', detector_mensaje, '0']
- [sincronismo_bit, '0', bits_rx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
